RDEPENDS_${PN} += "\
    packagegroup-agl-graphical-services \
"

RDEPENDS_${PN}_append = " systemd-agl-sync run-agl-postinsts"

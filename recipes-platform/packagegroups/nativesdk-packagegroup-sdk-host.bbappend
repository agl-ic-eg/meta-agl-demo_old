RDEPENDS_${PN} =+ "nativesdk-af-main-tools nativesdk-af-binder-devtools"
RDEPENDS_${PN} += "nativesdk-low-level-can-generator \
		nativesdk-cmake-apps-module \
		nativesdk-cmake-apps-module-doc \
"


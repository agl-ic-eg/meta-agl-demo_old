inherit packagegroup

RDEPENDS:${PN} += "\
"

LICENSE = "MIT"


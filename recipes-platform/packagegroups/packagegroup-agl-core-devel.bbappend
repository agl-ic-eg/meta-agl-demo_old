RDEPENDS_${PN}_append = "\
        pyagl \
        gcov \
        gcov-symlinks \
        gcovr \
        gcovr-wrapper \
        jq \
        htop \
        tree \
"

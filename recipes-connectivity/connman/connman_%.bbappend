require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'connman_agldemo.inc', '', d)}

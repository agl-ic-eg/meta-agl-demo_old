require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'flutter-gallery-release_agldemo.inc', '', d)}

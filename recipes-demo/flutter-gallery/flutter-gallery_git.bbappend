require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'flutter-gallery_agldemo.inc', '', d)}
